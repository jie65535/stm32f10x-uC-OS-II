# Keil uVision project Project.uvprojx, settings and files
target Project (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Porject +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\App;..\STM32F10x\CMSIS;..\STM32F10x\CONFIG;..\STM32F10x\FWLib\inc;..\uCOS-II\Ports;..\uCOS-II\Source;..\uCOS-II\Config;..\uCOS-II_Task
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../App/: SerialPort.c
  group Project
    ./: main.c
  group uCOS-II_Task
    ../uCOS-II_Task/: task.h start_task.c test_task.c
  group uCOS-II\Config
    ../uCOS-II/Config/: app_cfg.c app_cfg.h includes.h os_cfg.h os_dbg.c
  group STM32F10x\CONFIG
    ../STM32F10x/CONFIG/: stm32f10x_it.c
  group Doc
    ../Doc/: Readme.txt
  group STM32F10x\CMSIS
    ../STM32F10x/CMSIS/: core_cm3.c system_stm32f10x.c
  group STM32F10x\CMSIS\startup
    ../STM32F10x/CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group STM32F10x\FWLib
    ../STM32F10x/FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group uCOS-II\Ports
    ../uCOS-II/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uCOS-II\Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
